# IAR project sd_init.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-1s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm8.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-0t-n.h
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
  group (top)
    ./: AT45DB321E_Setup.c AT45DB321E_Setup.h EEPROM_Secure_Read.c EEPROM_Secure_Read.h Flash_Data_Read.c Flash_Data_Read.h General.h I2C_ACK_NACK_Generation.c I2C_ACK_NACK_Generation.h I2C_Protocol.c I2C_Protocol.h IO_Module.c IO_Module.h Learn_Mode.c Learn_Mode.h Main.cpp Main.h Test_Mode.c Test_Mode.h
